## temp/midas-driver/src/Kconfig
```kconfig
config MIDAS-DRIVER
	tristate "Midas-driver"
        default m
	help
	  This is an test for midas-driver
```
